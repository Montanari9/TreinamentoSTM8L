# IAR project ex1.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: STM8L10x_StdPeriph_Driver\inc; $PROJ_DIR$
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c stm8l10x_it.c
  group FwLib
    STM8L10x_StdPeriph_Driver/src/: stm8l10x_awu.c stm8l10x_clk.c stm8l10x_exti.c stm8l10x_flash.c stm8l10x_gpio.c stm8l10x_tim4.c stm8l10x_usart.c
